<?xml version='1.0' encoding='UTF-8'?>
<workspace>
  <project>
    </project>
  <project>
    <path>$WS_DIR$\Project.ewp</path>
  </project>
  <batchBuild>
    </batchBuild>
</workspace>