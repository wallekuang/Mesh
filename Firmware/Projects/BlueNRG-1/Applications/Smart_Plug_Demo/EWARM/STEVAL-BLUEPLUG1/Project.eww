<?xml version='1.0' encoding='UTF-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\Project.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>release</name>
            <member>
                <project>BlueNRG_Mesh_Lib</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>Lighting</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>release_X-NUCLEO-LED61A1</name>
            <member>
                <project>BlueNRG_Mesh_Lib</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>Lighting_X-NUCLEO-LED61A1_OnOff</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>